options:
  parameters:
    generate_options: qt_gui
    id: exp6
    output_language: python
    title: Access-Code Frame Detection
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '128'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: frame_start
    name: Access Code Detection
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1,0,1,1,0,0,1,0, 0,1,1,0,0,1,0,1]'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10110010'
    tagname: frame_start
    threshold: '0'
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [blocks_head_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle2_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
